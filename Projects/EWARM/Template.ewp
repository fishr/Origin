# IAR project Template.ewp, settings and files
configuration Template (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_DEFAULT_TIMEOUT_CALLBACK; EMPL_TARGET_STM32F4; MPU9250; COMPASS_ENABLED
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32F429I-Discovery; ..\..\Drivers\STM32F4xx_StdPeriph_Driver\inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\core\mpl; ..\..\Drivers\core\mllite; ..\..\Drivers\core\eMPL-hal; ..\..\Drivers\core\driver\eMPL; ..\..\Inc; ..\..\Drivers\core\driver\include; ..\..\Drivers\core\driver\stm32L
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\Drivers\core\mpl\libmpllib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
  group MPU9250_Lib/driver/eMPL
    ../../Drivers/core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group MPU9250_Lib/driver/stm32l
    ../../Drivers/core/driver/stm32L/: log_stm32.c
  group MPU9250_Lib/eMPL-hal
    ../../Drivers/core/eMPL-hal/: eMPL_outputs.c
  group MPU9250_Lib/mllite
    ../../Drivers/core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU9250_Lib/mpl
    ../../Drivers/core/mpl/: accel_auto_cal.h compass_vec_cal.h fast_no_motion.h fusion_9axis.h gyro_tc.h heading_from_gyro.h inv_math.h invensense_adv.h mag_disturb.h motion_no_motion.h no_gyro_fusion.h quaternion_supervisor.h
  group STM32F4xx_StdPeriph_Driver
    ../../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../../Src/: adc.c Button.c fonts.c gpio.c gps.c gui.c i2c.c imu.c latlong.c lcd.c main.c spi.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f4xx_it.c system_stm32f4xx.c tick.c uart.c xbee.c
