# IAR project LTDC_ColorKeying.ewp, settings and files
configuration LTDC_ColorKeying (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM32F429I_DISCO
  ICCARM.CCIncludePath2: ..\; ..\..\Inc; ..\..\Drivers\STM32F4xx_StdPeriph_Driver\inc; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LTDC_ColorKeying.srec
  ILINK.IlinkOutputFile: LTDC_ColorKeying.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429xx.s
  group STM32F429I-Discovery
    ../: stm32f429i_discovery.h stm32f429i_discovery_lcd.c stm32f429i_discovery_lcd.h stm32f429i_discovery_sdram.c stm32f429i_discovery_sdram.h
  group STM32F4xx_StdPeriph_Driver
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
    ../../Drivers/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c
  group User
    ../: main.c stm32f4xx_conf.h stm32f4xx_it.c system_stm32f4xx.c
