# IAR project Template.ewp, settings and files
configuration Template (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32F429I-Discovery; C:\Users\Ryan\Documents\IAR Embedded Workbench\Origin\Drivers\STM32F4xx_StdPeriph_Driver\inc; C:\Users\Ryan\Documents\IAR Embedded Workbench\Origin\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../: gpio.c main.c stm32f4xx_it.c system_stm32f4xx.c tick.c
