<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Template</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\..\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f429_439xx.s</name>
    </file>
  </group>
  <group>
    <name>MPU9250_Lib</name>
    <group>
      <name>driver</name>
      <group>
        <name>eMPL</name>
        <file>
          <name>$PROJ_DIR$\..\core\driver\eMPL\inv_mpu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\core\driver\eMPL\inv_mpu_dmp_motion_driver.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>eMPL-hal</name>
      <file>
        <name>$PROJ_DIR$\..\core\eMPL-hal\eMPL_outputs.c</name>
      </file>
    </group>
    <group>
      <name>mllite</name>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\data_builder.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\hal_outputs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\message_layer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\ml_math_func.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\mlmath.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\mpl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\results_holder.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\start_manager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\core\mllite\storage_manager.c</name>
      </file>
    </group>
    <group>
      <name>mpl</name>
      <file>
        <name>$PROJ_DIR$\..\core\mpl\libmpllib.a</name>
      </file>
    </group>
  </group>
  <group>
    <name>STM32F4xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma2d.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sai.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\button.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\gps.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32f4xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\system_stm32f4xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\tick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\uart.c</name>
    </file>
  </group>
</project>


